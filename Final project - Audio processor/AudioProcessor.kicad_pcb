# Repository gastonvallasciani/CESE-6Co2018_PCB

File README.md:

# CESE-6Co2018_PCB
Poncho Procesador de Audio

El Poncho "Procesador de Audio" es una placa de circuito impreso que se diseño para ser montada sobre la EDU-CIAA-NXP. Dicho pcb le brinda a la EDU-CIAA-NXP el hardware necesario para adquirir audio en modo estereo o en modo mono estereo, y además, el hardware necesario para generar el audio procesado en modo stereo o mono stereo. A su vez, se agrega hardware indicador de estado para el usuario y se agregan protecciones contra el mal uso del equipo.

Para la generación de audio el poncho posee un DAC PCM5100 para la generación de audio estéreo con un pin de Mute para poder controlar el encendido y apagado de la salida mediante un pin del lpc4337. Además, posee mapeado a la salida el DAC de salida de la EDU-CIAA-NXP para poder generar una salida mono stereo.

Para la adquisición de audio el poncho posee accesibles los canales 1 y 2 del ADC de la EDU-CIAA-NXP mediante el hardware pertinente para realizar el ajuste de niveles de entrada. Este incluye el agregado de un nivel de continua a la señal de audio adquirida, un ajuste de volumen y las protecciones pertinentes para la entrada del ADC. 

Se deja una bornera para acceder al I2C y UART del LPC4337.

A su vez, el pcb posee hardware para poder trabajar en modo monoestereo. Este, suma un nivel de continua, canal derecho y canal izquierdo mediante un amplificador operacional. 

Para las entradas y salidas de audio se utilizarán conectores miniplug de 3.5mm(4 en total).

Por último, se incluirán 3 leds para usar a modo de indicación de nivel de entrada y un buzzer.

## KiCad design Final project - Audio processor/AudioProcessor.kicad_pcb

Parts:
C1, C2, C9, C10: 100uF; CP_Elec_6.3x5.3
C3, C6, C11, C13, C16, C21, C25: 0.1uF; C_1206_HandSoldering
C4, C8: 470uF; CP_Radial_D10.0mm_P5.00mm
C5: 0.1Uf; C_1206_HandSoldering
C7, C12, C14, C17, C19, C20, C22, C26: 10uF; CP_Elec_5x5.3
C15: 2.2UF; CP_Radial_D5.0mm_P2.50mm
C18: 2.2uF; CP_Radial_D5.0mm_P2.50mm
C23, C24: 2.2nF; C_1206_HandSoldering
D1, D2, D4: LED; LED_1206_HandSoldering
D3: 1N4148; D_A-405_P10.16mm_Horizontal
J1: INPUT STEREO; BARREL_JACK
J2: INPUT MONO STEREO; BARREL_JACK
J3: ALIMENTACION; TerminalBlock_Phoenix_MKDS1.5-3pol
J4: JCH1; Pin_Header_Straight_1x02_Pitch2.54mm
J5: JCH2; Pin_Header_Straight_1x02_Pitch2.54mm
J6: SPI & I/0; Socket_Strip_Straight_2x05_Pitch2.54mm
J7: I2C & RS232; Socket_Strip_Straight_2x05_Pitch2.54mm
J8: JCH3; Pin_Header_Straight_1x02_Pitch2.54mm
J9: OUTPUT STEREO; BARREL_JACK
J10: OUTPUT MONO STEREO; BARREL_JACK
Q2: Q; TO-92_Molded_Narrow
Q3, Q4: Q_NPN_BCE; TO-92_Molded_Narrow
R1, R2, R3, R4, R13, R14, R24, R27, R31: 1K; R_1206_HandSoldering
R5, R7, R15: 10K; Potentiometer_Trimmer_Bourns_3296W
R6, R8, R9, R10, R16, R17, R18, R19, R25, R29, R30, R34, R35, R36, R37: 10K; R_2010_HandSoldering
R11, R12, R20: 100K; Potentiometer_Trimmer_Bourns_3296W
R23: 10k; R_2010_HandSoldering
R26: 5K9; R_1206_HandSoldering
R28: 0R; R_1206_HandSoldering
R32, R33: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1, U2: LM2904; SOIC-8_3.9x4.9mm_Pitch1.27mm
U3: pcm5100; TSSOP-20_4.4x6.5mm_Pitch0.65mm
XA1: Conn_Poncho2P_2x_20x2; Conn_Poncho_Completo

Connections:
+3V3: C5.1, C6.1, C7.1, C8.1, C11.1, C12.1, C16.1, C19.1, C20.1, C21.1, C25.1, C26.1, J3.2, J6.2, J7.3, J7.4, R1.1, R3.1, R13.1, U1.8 (V+), U2.8 (V+), U3.1 (CPVDD), U3.8 (AVDD), U3.20 (DVDD), XA1.41 (+3.3V)
+5V: C3.1, C4.1, J3.1, J6.9, J7.1, J7.2, R24.1, R26.1, R27.1, R31.1, XA1.42 (+5V)
/AUDIO_MUTE: D3.1 (K), XA1.80 (GPIO8)
/BCK: U3.13 (BCK), XA1.55 (ethRCLCK)
/CH1ADC: J4.2, XA1.13 (ADC1)
/CH2ADC: J5.2, XA1.11 (ADC2)
/CH3ADC: J8.2, XA1.9 (ADC3)
/CS: J6.1, XA1.72 (GPIO1)
/DIN: U3.14 (DIN), XA1.46 (ethTXEN)
/GPIO0: J6.4, XA1.69 (GPIO0)
/GPIO2: J6.6, XA1.71 (GPIO2)
/GPIO3: J6.8, XA1.74 (GPIO3)
/I2CSCL: J7.8, XA1.21 (i2cSCL)
/I2CSDA: J7.10, XA1.19 (i2cSDA)
/INLCHM: J2.1, R16.2
/INLCHS: J1.1, R6.2
/INRCHM: J2.2, R17.2
/INRCHS: J1.2, R8.2
/L4: R23.1, XA1.73 (GPIO4)
/L5: R25.1, XA1.76 (GPIO5)
/L6: R30.1, XA1.75 (GPIO6)
/LRCK: U3.15 (LRCK), XA1.44 (ethRXD1)
/MUTE: C17.1, D3.2 (A), R26.2, R29.1, U3.17 (XSMT)
/OFFSETCHM: C9.2, C10.2, R15.2, U2.3 (+)
/OFFSETLCHS: C1.2, R5.2, U1.3 (+)
/OFFSETRCHS: C2.2, R7.2, U1.5 (+)
/OUTDAC: C22.1, XA1.15 (DAC)
/OUTL: R33.2, U3.6 (OUTL)
/OUTR: R32.2, U3.7 (OUTR)
/SPI_MISO: J6.3, XA1.58 (spiMISO)
/SPI_MOSI: J6.5, XA1.61 (spiMOSI)
/SPI_SCK: J6.7, XA1.60 (spiSCK)
/rs232RXD: J7.7, XA1.23 (rs232RXD)
/rs232TXD: J7.9, XA1.25 (rs232TXD)
GND: C3.2, C4.2, C6.2, C8.2, C13.2, C14.2, C16.2, C17.2, C19.2, C23.2, J3.3, J6.10, J7.5, J7.6, Q2.3 (E), Q3.3 (E), Q4.3 (E), R28.1, R29.2, U3.10 (DEMP), U3.11 (FLT), U3.12 (SCK), U3.16 (FMT), U3.19 (DGND), XA1.20 (GND), XA1.22 (GND), XA1.24 (GND), XA1.26 (GND), XA1.28 (GND), XA1.30 (GND), XA1.32 (GND), XA1.38 (GND), XA1.40 (GND), XA1.43 (GND), XA1.45 (GND), XA1.47 (GND), XA1.51 (GND), XA1.53 (GND), XA1.57 (GND), XA1.59 (GND), XA1.65 (GND), XA1.67 (GND), XA1.77 (GND), XA1.79 (GND)
GNDA: C5.2, C7.2, C11.2, C12.2, C15.2, C20.2, C21.2, C24.2, C25.2, C26.2, J1.3, J2.3, J9.3, J10.3, R2.1, R4.1, R9.2, R10.2, R14.1, R18.2, R19.2, R28.2, R34.1, R35.2, R36.1, R37.1, U1.4 (V-), U2.4 (V-), U3.3 (CPGND), U3.9 (AGND), XA1.8 (GNDA), XA1.10 (GNDA), XA1.12 (GNDA), XA1.14 (GNDA), XA1.16 (GNDA), XA1.18 (GNDA)
unnamed: C1.1, R6.1, R9.1
unnamed: C2.1, R8.1, R10.1
unnamed: C9.1, R16.1, R18.1
unnamed: C10.1, R17.1, R19.1
unnamed: C13.1, C14.1, U3.18 (LDOO)
unnamed: C15.1, U3.5 (VNEG)
unnamed: C18.1, U3.2 (CAPP)
unnamed: C18.2, U3.4 (CAPM)
unnamed: C22.2, J10.1, J10.2, R37.2
unnamed: C23.1, J9.2, R32.1
unnamed: C24.1, J9.1, R33.1
unnamed: D1.1 (K), Q2.2 (C)
unnamed: D1.2 (A), R24.2
unnamed: D2.1 (K), Q3.2 (C)
unnamed: D2.2 (A), R27.2
unnamed: D4.1 (K), Q4.2 (C)
unnamed: D4.2 (A), R31.2
unnamed: J4.1, R11.2, U1.1
unnamed: J5.1, R12.2, U1.7
unnamed: J8.1, R20.2, U2.1
unnamed: Q2.1 (B), R23.2
unnamed: Q3.1 (B), R25.2
unnamed: Q4.1 (B), R30.2
unnamed: R1.2, R5.1
unnamed: R2.2, R5.3
unnamed: R3.2, R7.1
unnamed: R4.2, R7.3
unnamed: R11.3, R34.2, U1.2 (-)
unnamed: R12.3, R35.1, U1.6 (-)
unnamed: R13.2, R15.1
unnamed: R14.2, R15.3
unnamed: R20.3, R36.2, U2.2 (-)

Notes on the sheet:
DAC STEREO
VOLUME MONO STEREO
VOLUME LCH STEREO
VOLUME RCH STEREO
AUDIO STEREO INPUT
AUDIO MONO STEREO INPUT
AUDIO STEREO OUTPUT
AUDIO MONO STEREO OUTPUT
OFFSET RCH STEREO
OFFSET LCH STEREO
OFFSET MONO STEREO

Board: 2 copper layers, 85.9 x 137.0 mm, 87 parts (0 on the bottom side), 68 nets.

Other parts of the board:
G101: Logo_OSHWA
H2, H2#2, H2#3, H2#4: PCB_HOLE; Led_Hole

## Commit log

2018-09-16 Se agrega en el repo la primer version del esquematico
2018-09-16 se agrega el esquematico en pdf
2018-09-16 Se actualiza el esquematico
2018-09-26 Se actualizo el esquematico
2018-10-12 Actualizacion, esquematico completo, pcb iniciado
2018-10-13 Actualizacion repo
2018-10-14 Se actualiza el PCB, todavia queda rutear un poco.
2018-10-20 avanzando con el pcb
2018-10-21 Terminando el PCB
2018-10-22 Placa final
2018-11-11 Version 2 del pcb del procesador de audio
2018-11-14 version Final
2018-11-14 se agrega lo ultimo
